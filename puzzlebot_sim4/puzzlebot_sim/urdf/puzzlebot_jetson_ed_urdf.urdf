Commit message: Corregir posición de llantas

File: puzzlebot_sim4/puzzlebot_sim/urdf/puzzlebot_jetson_ed_urdf.urdf (robot description, URDF)
Before this commit: robot Puzzlebot Jetson-Lidar Ed., 4 links, 3 joints
Joints:
- joint lw_joint: origin xyz=0.055 0.087 0.0046 -> xyz=0.055 0.19 0.0046
